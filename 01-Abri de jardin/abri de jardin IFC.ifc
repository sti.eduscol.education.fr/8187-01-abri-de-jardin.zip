Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\arago\Desktop\abri de jardin entaillages des chevrons et maison.ifc
Time: 2015-12-15T13:18:07
Made in: Cadwork

# IfcBuildingStorey, Storey 1
Elevation: 0 m

# IfcBeam (22)
In: Storey 1
Pset_Cadwork_3d - Material_Name: Douglas
Name | Prod_Nb
4 x Lien Face | 10
2 x Arbalétrier | 8
2 x Entrait | 9
4 x Lien | 11
7 x Chevron | 13
Panne intermédiaire | 7
Sablière | 6
Faîtière | 5

# IfcBuildingElementProxy (3)
In: Storey 1
Pset_Cadwork_3d - Prod_Nb: 12; Material_Name: Douglas

# IfcMember (4)
In: Storey 1
Pset_Cadwork_3d - Material_Name: Douglas
Name | Prod_Nb
Poteau arrière | 2
Poteau arrière | 4
Poteau arrière | 3
Poteau arrière | 1
